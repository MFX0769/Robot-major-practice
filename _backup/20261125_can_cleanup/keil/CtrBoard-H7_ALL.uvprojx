# Keil uVision project CtrBoard-H7_ALL.uvprojx, settings and files
target CtrBoard-H7_ALL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: CtrBoard-H7_ALL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx,ARM_MATH_CM7,__FPU_PRESENT=1U
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../App/inc;../Bsp/inc;../vofa+;../Algorithm/inc;../Application;../Protocol;../Comm;../System;../UI;../Math;../Tool;../Tool/debug;../Bsp/taurus;../Bsp
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../vofa+/: vofa.c
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c fdcan.c octospi.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_ospi.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Bsp
    ../Bsp/: bsp_user_key.c bsp_buzzer.c lcd.c ws2812.c BMI088driver.c BMI088Middleware.c w25q64.c bsp_imu_bridge.c soft_i2c.c
  group App
    ../App/: key_task.c lcd_task.c imu_task.c
  group Algprithm
    ../Algorithm/: MahonyAHRS.c user_lib.c
  group Application
    ../Application/: gimbal_task.c gimbal_task.h debug_task.c debug_task.h mode_switch_task.c mode_switch_task.h shoot_task.c shoot_task.h control_def.h status_task.c status_task.h ui_task.c ui_task.h log_task.c log_task.h chassis_task.c chassis_task.h arm_task.c arm_task.h arm_ik.c arm_ik.h
  group Protocol
    ../Protocol/: prot_lk_motor.c prot_dr16.c prot_dbus.c prot_dbus.h prot_dm_motor.c prot_dm_motor.h prot_rm_motor.c prot_rm_motor.h prot_T_imu.c prot_T_imu.h prot_rm_judge.c prot_rm_judge.h prot_vision.c prot_vision.h prot_TriggerMotor.c prot_TriggerMotor.h prot_FricMotor.c prot_FricMotor.h prot_judge_send.c prot_judge_send.h prot_ws2812.c prot_ws2812.h prot_vtm.c prot_vtm.h prot_remote_fusion.c prot_remote_fusion.h prot_sbus.c prot_sbus.h prot_8irtraking.h prot_8irtraking.c prot_servo.c prot_servo.h prot_xb_servo.c prot_xb_servo.h servo_test.c servo_test.h
  group Application
    ../Application/: control_def.h
  group Comm
    ../Comm/: can_comm.c usart_comm.c i2c_comm.c usb_comm.c Vision_Send_task.c judge_comm.c judge_comm.h
  group UI
    ../UI/: ui_g.c ui_interface.c ui_g.h ui_interface.h ui_types.h ui.h
  group Debug
    ../Tool/debug/: dbg_print.c dbg_print.h
  group Math
    ../Math/: math_calcu.c math_calcu.h arm_math.h crc.c crc.h data_processing.c data_processing.h DataScope_DP.C DataScope_DP.h KalmanFilter.c KalmanFilter.h pid.c pid.h ubf.c ubf.h us_tim.c us_tim.h data_log.c data_log.h
    ../Math/DSP/: arm_cortexM7lfdp_math.lib
  group Bsp/taurus
    ../Bsp/taurus/: bsp_can.c bsp_gpio.c bsp_pwm.c bsp_usart.c
software components: CMSIS:CORE 4.3.0
